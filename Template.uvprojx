# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\Core;.\Library\inc;.\User;.\System\delay;.\System\sys;.\System\usart;.\Hardware;.\DRIVE\DRIVE_h;.\Hardware\Hardware_H;.\DRIVE;.\Hardware\L1-40
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Core
    ./Core/: startup_stm32f40_41xxx.s
  group User
    ./User/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group Library
    ./Library/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_syscfg.c stm32f4xx_iwdg.c stm32f4xx_wwdg.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_dcmi.c stm32f4xx_dma.c
  group System
    ./System/delay/: delay.c
    ./System/sys/: sys.c
    ./System/usart/: usart.c
  group Hardware
    ./Hardware/: display.c encode_init.c filter.c key.c lcd.c led.c ms53l1m.c pid.c pwm.c timer.c wit_c_sdk.c DIP.c Menu_UI.c Menu_UI.h Switch.c Switch.h
    ./Hardware/L1-40/: hal_drivers.c HEXProtocol.c ASCIIProtocol.c
